# Keil uVision project STM32F429 _uCOS_III.uvprojx, settings and files
target stM32F429 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429BGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 _uCOS_III
  c flags: Optim=1 OneElfS=1
  c define: STM32F429_439xx
  c include: ..\APP;..\BSP;..\uC-CPU;..\uC-LIB;..\uCOS-III\Source;..\uCOS-III\Ports;..\LIB\STM32F4xx\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f429_439xx.s system_stm32f4xx.c
  group APP
    ../APP/: app.c TASK_thread_bms.c TASK_thread_cam.c TASK_thread_collect.c TASK_thread_gyr.c TASK_thread_hum.c TASK_thread_ioc.c TASK_thread_tel.c TASK_thread_ult.c stm32f4xx_it.c task_variable.c
  group BSP
    ../BSP/: bsp.c BSP_LED.c BSP_bms.c BSP_camera.c BSP_gyroscope.c BSP_humiture.c bsp_int.c BSP_iocontrol.c bsp_periph.c BSP_telecontrol.c BSP_ultrasonic.c
  group uC-CPU
    ../uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOS-III-Source
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III-Ports
    ../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
software components: CMSIS:CORE 4.1.0
